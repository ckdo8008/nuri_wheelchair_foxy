Commit message: 휠체어 ros

File: nuri_description/urdf/nuri_wheelchair.urdf (robot description, URDF)
Before this commit: robot nuri_wheelchair, 12 links, 11 joints
Joints:
- joint wheel_left_joint: type fixed -> continuous
- joint wheel_right_joint: type fixed -> continuous
